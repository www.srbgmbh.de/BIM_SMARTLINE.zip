Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-08-31T11:50:37+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternativ-UI 23.0.11.19

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: SMARTLINE E300:SMARTLINE E300 - 190 lm - Zentralbatterie, SMARTLINE E300:SMARTLINE E300 - 190 lm - Zentralbatterie:2487342
In: Default
Type - Material: RAL 9016
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: SMARTLINE E300 - 190 lm - Zentralbatterie; sets with these values: 2
